# Keil uVision project STM32_MWD.uvprojx, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_MWD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Hardware\LED;.\Hardware\KEY;.\Hardware\TOUCH_KEY;.\Basic\usart;.\Basic\i2c;.\Hardware\CAN;.\Basic\adc;.\Basic\tim;.\Hardware\PSCXX;.\Basic\modbus;.\Basic\iwdg;.\User;.\Basic\exti
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_exti.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c data_receive.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/adc/: adc.c
    ./Basic/tim/: tim.c
    ./Basic/modbus/: modbus.c
    ./Basic/iwdg/: iwdg.c
    ./Basic/exti/: exti.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/PSCXX/: pscxx.c
